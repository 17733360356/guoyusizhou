# Keil uVision project STM32-DEMO.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: STM32F10X_HD  USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\BSP\CONTROL;..\BSP\IIC;..\BSP\IMU;..\BSP\MOTOR;..\BSP\MPU6050;..\BSP\PWM_IN;..\BSP\TIM;..\BSP\UART;..\BSP\Delay;..\BSP\HMC5883;..\BSP\ADC;..\BSP\KEY;..\BSP\OLED;..\BSP\APP;..\BSP\PARAM;..\BSP\NRF24L01;..\BSP\SPI;..\BSP\MS5611;..\BSP\EEPROM;..\BSP\STMFLASH;..\nmea_decode\include\nmea;..\usart;..\gps;..\ff9;..\sdcard;..\nmea_decode\include\nmea;..\gps;..\BSP\send;..\BSP\sys;..\BSP\BEEP;..\BSP\LED;..\BSP\HC05
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYS
    ./: main.c stm32f10x_it.c
    ../usart/: bsp_usart1.c bsp_usart2.c
  group BSP
    ../BSP/ADC/: adc.c
    ../BSP/LED/: led.c
    ../BSP/SPI/: Spi.c
    ../BSP/IIC/: I2C.c
    ../BSP/KEY/: KEY.c
    ../BSP/OLED/: oled.c
    ../BSP/MOTOR/: moto.c
    ../BSP/TIM/: time.c
    ../BSP/UART/: usart.c
    ../BSP/Delay/: delay.c
    ../BSP/EEPROM/: eeprom.c
    ../BSP/MS5611/: MS5611.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/HMC5883/: hmc5883.c
    ../BSP/NRF24L01/: NRF24L01.c
    ../BSP/PWM_IN/: Tim_PWM_IN.c
    ../BSP/STMFLASH/: stmflash.c
    ../gps/: gps_config.c nema_decode_test.c
    ../sdcard/: bsp_sdio_sdcard.c
    ../BSP/send/: send.c
    ../BSP/sys/: sys.c
    ../BSP/BEEP/: beep.c
    ../BSP/HC05/: hc05.c
  group APP
    ../BSP/IMU/: IMU.c
    ../BSP/APP/: app.c
    ../BSP/PARAM/: Param.c
    ../BSP/CONTROL/: CONTROL.c
  group nmealib
    ../nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c tok.c time_gps.c
  group ftt9
    ../ff9/: diskio.c ff.c
    ../ff9/option/: ccsbcs.c
